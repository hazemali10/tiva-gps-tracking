# Keil uVision project GPS_TRACKING.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS_TRACKING
  c flags: Optim=1
  c include: .\INC\HAL;.\INC\MCAL;.\SERVICES
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/: main.c
  group HAL
    ./SRC/HAL/: gps.c lcd.c
  group MCAL
    ./SRC/MCAL/: gpio.c uart.c
  group SERVICES
    ./SERVICES/: tm4c123gh6pm.h bit_utils.h
  group START
    ./START/: startup_TM4C123.s system_TM4C123.c
